# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: ..\HALDriver\Inc;..\CMSIS;..\User;..\Bsp\print;..\Bsp\baisctime;..\Bsp\encoder;..\Bsp\key;..\Bsp\oled;..\Bsp\display;..\Bsp\sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --libpath=D:\Project\Keil_v5\ARM\ARMCC\lib
  group HalDriver
    ../HALDriver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group StartUp
    ../CMSIS/: startup_stm32f103xe.s
  group User
    ../User/: stm32f1xx_it.c main.c
  group CMSIS
    ../CMSIS/: system_stm32f1xx.c
  group Bsp
    ../Bsp/key/: key.c
    ../Bsp/oled/: oled.c
    ../Bsp/display/: display.c
    ../Bsp/sensor/: sensor.c
